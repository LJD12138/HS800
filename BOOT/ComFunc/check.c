/*******************************************************************************************************************************
 * Project : BOOT
 * Module  : BOOT\ComFunc
 * File    : check.c
 * Date    : 2026-09-20
 * Author  : LJD(291483914@qq.com)
 * Desc    : 数据校验算法库实现，包含累加和、CRC8、CRC16及CRC32算法
 * -------------------------------------------------------
 * todo    :
 * 1. none
 * -------------------------------------------------------
 * Copyright (c) 2026 -inc
 *******************************************************************************************************************************/

//****************************************************Includes******************************************************************//
#include "check.h"
#include "function.h"

#if (1)
//****************************************************Macros********************************************************************//

//****************************************************Parameter Initialization**************************************************//

/* CRC8 查表法常量表 (X8+X2+X1+1, Poly = 0x07) */
static const uint8_t S_ucaCrc8Table[256] =
{
	0x00,0x07,0x0E,0x09,0x1C,0x1B,0x12,0x15,0x38,0x3F,0x36,0x31,0x24,0x23,0x2A,0x2D,
	0x70,0x77,0x7E,0x79,0x6C,0x6B,0x62,0x65,0x48,0x4F,0x46,0x41,0x54,0x53,0x5A,0x5D,
	0xE0,0xE7,0xEE,0xE9,0xFC,0xFB,0xF2,0xF5,0xD8,0xDF,0xD6,0xD1,0xC4,0xC3,0xCA,0xCD,
	0x90,0x97,0x9E,0x99,0x8C,0x8B,0x82,0x85,0xA8,0xAF,0xA6,0xA1,0xB4,0xB3,0xBA,0xBD,
	0xC7,0xC0,0xC9,0xCE,0xDB,0xDC,0xD5,0xD2,0xFF,0xF8,0xF1,0xF6,0xE3,0xE4,0xED,0xEA,
	0xB7,0xB0,0xB9,0xBE,0xAB,0xAC,0xA5,0xA2,0x8F,0x88,0x81,0x86,0x93,0x94,0x9D,0x9A,
	0x27,0x20,0x29,0x2E,0x3B,0x3C,0x35,0x32,0x1F,0x18,0x11,0x16,0x03,0x04,0x0D,0x0A,
	0x57,0x50,0x59,0x5E,0x4B,0x4C,0x45,0x42,0x6F,0x68,0x61,0x66,0x73,0x74,0x7D,0x7A,
	0x89,0x8E,0x87,0x80,0x95,0x92,0x9B,0x9C,0xB1,0xB6,0xBF,0xB8,0xAD,0xAA,0xA3,0xA4,
	0xF9,0xFE,0xF7,0xF0,0xE5,0xE2,0xEB,0xEC,0xC1,0xC6,0xCF,0xC8,0xDD,0xDA,0xD3,0xD4,
	0x69,0x6E,0x67,0x60,0x75,0x72,0x7B,0x7C,0x51,0x56,0x5F,0x58,0x4D,0x4A,0x43,0x44,
	0x19,0x1E,0x17,0x10,0x05,0x02,0x0B,0x0C,0x21,0x26,0x2F,0x28,0x3D,0x3A,0x33,0x34,
	0x4E,0x49,0x40,0x47,0x52,0x55,0x5C,0x5B,0x76,0x71,0x78,0x7F,0x6A,0x6D,0x64,0x63,
	0x3E,0x39,0x30,0x37,0x22,0x25,0x2C,0x2B,0x06,0x01,0x08,0x0F,0x1A,0x1D,0x14,0x13,
	0xAE,0xA9,0xA0,0xA7,0xB2,0xB5,0xBC,0xBB,0x96,0x91,0x98,0x9F,0x8A,0x8D,0x84,0x83,
	0xDE,0xD9,0xD0,0xD7,0xC2,0xC5,0xCC,0xCB,0xE6,0xE1,0xE8,0xEF,0xFA,0xFD,0xF4,0xF3
};

/* MODBUS-CRC16 高位字节值表 */
static const uint8_t S_ucaCrcHi[256] =
{
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
	0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
	0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40 
};

/* MODBUS-CRC16 低位字节值表 */
static const uint8_t S_ucaCrcLo[256] =
{
	0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 
	0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 
	0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 
	0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 
	0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4, 
	0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3, 
	0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 
	0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 
	0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 
	0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 
	0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED, 
	0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26, 
	0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 
	0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 
	0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 
	0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 
	0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 
	0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5, 
	0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 
	0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 
	0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 
	0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 
	0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B, 
	0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C, 
	0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 
	0x43, 0x83, 0x41, 0x81, 0x80, 0x40 
};

/* CRC16-MSB 查表法常量表 (X16+X15+X2+X1, Poly = 0x8005) */
static const uint16_t S_usaCrc16MsbTable[256] =
{
    0x0000, 0x8005, 0x800F, 0x000A, 0x801B, 0x001E, 0x0014, 0x8011,
    0x8033, 0x0036, 0x003C, 0x8039, 0x0028, 0x802D, 0x8027, 0x0022,
    0x8063, 0x0066, 0x006C, 0x8069, 0x0078, 0x807D, 0x8077, 0x0072,
    0x0050, 0x8055, 0x805F, 0x005A, 0x804B, 0x004E, 0x0044, 0x8041,
    0x80C3, 0x00C6, 0x00CC, 0x80C9, 0x00D8, 0x80DD, 0x80D7, 0x00D2,
    0x00F0, 0x80F5, 0x80FF, 0x00FA, 0x80EB, 0x00EE, 0x00E4, 0x80E1,
    0x00A0, 0x80A5, 0x80AF, 0x00AA, 0x80BB, 0x00BE, 0x00B4, 0x80B1,
    0x8093, 0x0096, 0x009C, 0x8099, 0x0088, 0x808D, 0x8087, 0x0082,
    0x8183, 0x0186, 0x018C, 0x8189, 0x0198, 0x819D, 0x8197, 0x0192,
    0x01B0, 0x81B5, 0x81BF, 0x01BA, 0x81AB, 0x01AE, 0x01A4, 0x81A1,
    0x01E0, 0x81E5, 0x81EF, 0x01EA, 0x81FB, 0x01FE, 0x01F4, 0x81F1,
    0x81D3, 0x01D6, 0x01DC, 0x81D9, 0x01C8, 0x81CD, 0x81C7, 0x01C2,
    0x0140, 0x8145, 0x814F, 0x014A, 0x815B, 0x015E, 0x0154, 0x8151,
    0x8173, 0x0176, 0x017C, 0x8179, 0x0168, 0x816D, 0x8167, 0x0162,
    0x8123, 0x0126, 0x012C, 0x8129, 0x0138, 0x813D, 0x8137, 0x0132,
    0x0110, 0x8115, 0x811F, 0x011A, 0x810B, 0x010E, 0x0104, 0x8101,
    0x8303, 0x0306, 0x030C, 0x8309, 0x0318, 0x831D, 0x8317, 0x0312,
    0x0330, 0x8335, 0x833F, 0x033A, 0x832B, 0x032E, 0x0324, 0x8321,
    0x0360, 0x8365, 0x836F, 0x036A, 0x837B, 0x037E, 0x0374, 0x8371,
    0x8353, 0x0356, 0x035C, 0x8359, 0x0348, 0x834D, 0x8347, 0x0342,
    0x03C0, 0x83C5, 0x83CF, 0x03CA, 0x83DB, 0x03DE, 0x03D4, 0x83D1,
    0x83F3, 0x03F6, 0x03FC, 0x83F9, 0x03E8, 0x83ED, 0x83E7, 0x03E2,
    0x83A3, 0x03A6, 0x03AC, 0x83A9, 0x03B8, 0x83BD, 0x83B7, 0x03B2,
    0x0390, 0x8395, 0x839F, 0x039A, 0x838B, 0x038E, 0x0384, 0x8381,
    0x0280, 0x8285, 0x828F, 0x028A, 0x829B, 0x029E, 0x0294, 0x8291,
    0x82B3, 0x02B6, 0x02BC, 0x82B9, 0x02A8, 0x82AD, 0x82A7, 0x02A2,
    0x82E3, 0x02E6, 0x02EC, 0x82E9, 0x02F8, 0x82FD, 0x82F7, 0x02F2,
    0x02D0, 0x82D5, 0x82DF, 0x02DA, 0x82CB, 0x02CE, 0x02C4, 0x82C1,
    0x8243, 0x0246, 0x024C, 0x8249, 0x0258, 0x825D, 0x8257, 0x0252,
    0x0270, 0x8275, 0x827F, 0x027A, 0x826B, 0x026E, 0x0264, 0x8261,
    0x0220, 0x8225, 0x822F, 0x022A, 0x823B, 0x023E, 0x0234, 0x8231,
    0x8213, 0x0216, 0x021C, 0x8219, 0x0208, 0x820D, 0x8207, 0x0202
};

/* CRC16-LSB 查表法常量表 (X16+X15+X2+X1, Poly = 0xA001) */
static const uint16_t S_usaCrc16LsbTable[256] =
{
    0x0000, 0xC0C1, 0xC181, 0x0140, 0xC301, 0x03C0, 0x0280, 0xC241,
    0xC601, 0x06C0, 0x0780, 0xC741, 0x0500, 0xC5C1, 0xC481, 0x0440,
    0xCC01, 0x0CC0, 0x0D80, 0xCD41, 0x0F00, 0xCFC1, 0xCE81, 0x0E40,
    0x0A00, 0xCAC1, 0xCB81, 0x0B40, 0xC901, 0x09C0, 0x0880, 0xC841,
    0xD801, 0x18C0, 0x1980, 0xD941, 0x1B00, 0xDBC1, 0xDA81, 0x1A40,
    0x1E00, 0xDEC1, 0xDF81, 0x1F40, 0xDD01, 0x1DC0, 0x1C80, 0xDC41,
    0x1400, 0xD4C1, 0xD581, 0x1540, 0xD701, 0x17C0, 0x1680, 0xD641,
    0xD201, 0x12C0, 0x1380, 0xD341, 0x1100, 0xD1C1, 0xD081, 0x1040,
    0xF001, 0x30C0, 0x3180, 0xF141, 0x3300, 0xF3C1, 0xF281, 0x3240,
    0x3600, 0xF6C1, 0xF781, 0x3740, 0xF501, 0x35C0, 0x3480, 0xF441,
    0x3C00, 0xFCC1, 0xFD81, 0x3D40, 0xFF01, 0x3FC0, 0x3E80, 0xFE41,
    0xFA01, 0x3AC0, 0x3B80, 0xFB41, 0x3900, 0xF9C1, 0xF881, 0x3840,
    0x2800, 0xE8C1, 0xE981, 0x2940, 0xEB01, 0x2BC0, 0x2A80, 0xEA41,
    0xEE01, 0x2EC0, 0x2F80, 0xEF41, 0x2D00, 0xEDC1, 0xEC81, 0x2C40,
    0xE401, 0x24C0, 0x2580, 0xE541, 0x2700, 0xE7C1, 0xE681, 0x2640,
    0x2200, 0xE2C1, 0xE381, 0x2340, 0xE101, 0x21C0, 0x2080, 0xE041,
    0xA001, 0x60C0, 0x6180, 0xA141, 0x6300, 0xA3C1, 0xA281, 0x6240,
    0x6600, 0xA6C1, 0xA781, 0x6740, 0xA501, 0x65C0, 0x6480, 0xA441,
    0x6C00, 0xACC1, 0xAD81, 0x6D40, 0xAF01, 0x6FC0, 0x6E80, 0xAE41,
    0xAA01, 0x6AC0, 0x6B80, 0xAB41, 0x6900, 0xA9C1, 0xA881, 0x6840,
    0x7800, 0xB8C1, 0xB981, 0x7940, 0xBB01, 0x7BC0, 0x7A80, 0xBA41,
    0xBE01, 0x7EC0, 0x7F80, 0xBF41, 0x7D00, 0xBDC1, 0xBC81, 0x7C40,
    0xB401, 0x74C0, 0x7580, 0xB541, 0x7700, 0xB7C1, 0xB681, 0x7640,
    0x7200, 0xB2C1, 0xB381, 0x7340, 0xB101, 0x71C0, 0x7080, 0xB041,
    0x5000, 0x90C1, 0x9181, 0x5140, 0x9301, 0x53C0, 0x5280, 0x9241,
    0x9601, 0x56C0, 0x5780, 0x9741, 0x5500, 0x95C1, 0x9481, 0x5440,
    0x9C01, 0x5CC0, 0x5D80, 0x9D41, 0x5F00, 0x9FC1, 0x9E81, 0x5E40,
    0x5A00, 0x9AC1, 0x9B81, 0x5B40, 0x9901, 0x59C0, 0x5880, 0x9841,
    0x8801, 0x48C0, 0x4980, 0x8941, 0x4B00, 0x8BC1, 0x8A81, 0x4A40,
    0x4E00, 0x8EC1, 0x8F81, 0x4F40, 0x8D01, 0x4DC0, 0x4C80, 0x8C41,
    0x4400, 0x84C1, 0x8581, 0x4540, 0x8701, 0x47C0, 0x4680, 0x8641,
    0x8201, 0x42C0, 0x4380, 0x8341, 0x4100, 0x81C1, 0x8081, 0x4040
};


/***********************************************************************************************************************
 * 函数功能    : 数据比特翻转 (MSB 与 LSB 调换)
 * 说明(备注)  : 内部静态工具函数
 * 传入参数    : input: 待翻转数据; bits: 翻转比特位数
 * 输出参数    : 无
 * 返回值      : 翻转后的数值
 ************************************************************************************************************************/
static uint32_t ul_data_reflect(uint32_t input, uint8_t bits)
{
    uint32_t result = 0;

    for (uint8_t i = 0; i < bits; i++)
    {
        uint32_t bit = (uint32_t)((input >> i) & 1);
        bit = (uint32_t)(bit << (bits - 1 - i));
        result |= bit;
    }

    return result;
}

/***********************************************************************************************************************
 * 函数功能    : 累加和校验取反
 * 说明(备注)  : 计算字节累加和并取补码 (~sum + 1)
 * 传入参数    : p_str: 待校验数据指针; str_length: 待校验字节数
 * 输出参数    : 无
 * 返回值      : 8位校验和取反结果
 ************************************************************************************************************************/
uint8_t ucCheck_SumReflect(const uint8_t *p_str, int str_length)
{
    uint8_t uc_check_sum = 0;

    if (p_str == NULL || str_length <= 0)
        return 0;

    for (int i = 0; i < str_length; i++)
        uc_check_sum += p_str[i];

    return (uint8_t)((~uc_check_sum) + 1);
}

/***********************************************************************************************************************
 * 函数功能    : 累加和校验
 * 说明(备注)  : 计算字节序列的8位累加和
 * 传入参数    : p_str: 待校验数据指针; str_length: 待校验字节数
 * 输出参数    : 无
 * 返回值      : 8位累加和
 ************************************************************************************************************************/
uint8_t ucCheck_Sum(const uint8_t *p_str, int str_length)
{
    uint8_t uc_check_sum = 0;

    if (p_str == NULL || str_length <= 0)
        return 0;

    for (int i = 0; i < str_length; i++)
        uc_check_sum += p_str[i];

    return uc_check_sum;
}

/***********************************************************************************************************************
 * 函数功能    : CRC8查表法计算 (X8+X2+X1+1)
 * 说明(备注)  : 查表法快速计算
 * 传入参数    : p_data: 待校验数据指针; counter: 待校验长度
 * 输出参数    : 无
 * 返回值      : CRC8校验码
 ************************************************************************************************************************/
uint8_t ucCheck_CRC8cal(const uint8_t *p_data, uint8_t counter)
{
    uint8_t uc_crc8 = 0;

    if (p_data == NULL)
        return 0;

    while (counter--)
    {
        uc_crc8 = S_ucaCrc8Table[uc_crc8 ^ (*p_data)];
        p_data++;
    }

    return uc_crc8;
}

/***********************************************************************************************************************
 * 函数功能    : 通用 CRC8 计算
 * 说明(备注)  : 支持指定初始值、多项式以及反射模式
 * 传入参数    : init: 初始值; p_data: 待校验数据指针; length: 待校验长度; poly: 生成多项式; reflection: true-LSB模式, false-MSB模式
 * 输出参数    : 无
 * 返回值      : CRC8 校验值
 ************************************************************************************************************************/
uint8_t ucCheck_GetCrc8(uint8_t init, const uint8_t *p_data, uint16_t length, uint8_t poly, bool reflection)
{
    uint8_t i;
    uint8_t uc_crc = init;
    uint8_t uc_tmp;

    if (p_data == NULL)
        return init;

    while (length--)
    {
        uc_tmp = *p_data++;
        if (reflection)
            uc_tmp = (uint8_t)ul_data_reflect(uc_tmp, 8);

        uc_crc ^= uc_tmp;
        for (i = 8; i > 0; --i)
        {
            if (uc_crc & 0x80)
                uc_crc = (uint8_t)((uc_crc << 1) ^ poly);
            else
                uc_crc = (uint8_t)(uc_crc << 1);
        }
    }

    if (reflection)
        uc_crc = (uint8_t)ul_data_reflect(uc_crc, 8);

    return uc_crc;
}

/***********************************************************************************************************************
 * 函数功能    : 通用 CRC16 按位计算
 * 说明(备注)  : 内部静态通用核心函数
 * 传入参数    : init: 初始值; p_data: 数据指针; length: 长度; poly: 多项式; reflection: 反转模式; final_xor: 结果异或值
 * 输出参数    : 无
 * 返回值      : CRC16 计算值
 ************************************************************************************************************************/
static uint16_t us_crc16(uint16_t init, const uint8_t *p_data, uint16_t length, uint16_t poly, bool reflection, uint16_t final_xor)
{
    uint16_t us_crc = init;
    uint32_t ul_start = 0;

    if (p_data == NULL)
        return (init ^ final_xor);

    while (length-- > 0)
    {
        uint8_t uc_bt = p_data[ul_start++];
        if (reflection)
            uc_bt = (uint8_t)ul_data_reflect(uc_bt, 8);

        for (int i = 0; i < 8; i++)
        {
            bool b_msb_crc  = (bool)((us_crc & 0x8000U) != 0);
            bool b_msb_data = (bool)((uc_bt & 0x80U) != 0);
            if (b_msb_crc != b_msb_data)
                us_crc = (uint16_t)((us_crc << 1) ^ poly);
            else
                us_crc <<= 1;

            uc_bt <<= 1;
        }
    }

    if (reflection)
        us_crc = (uint16_t)ul_data_reflect(us_crc, 16);

    us_crc ^= final_xor;
    return us_crc;
}

/***********************************************************************************************************************
 * 函数功能    : CRC16-CCITT 计算 (Poly = 0x1021)
 * 说明(备注)  : MSB 模式
 * 传入参数    : init: 初始值; p_data: 待校验数据指针; length: 待校验长度
 * 输出参数    : 无
 * 返回值      : CRC16 校验值
 ************************************************************************************************************************/
uint16_t usCheck_CRC_CCITT(uint16_t init, const uint8_t *p_data, uint16_t length)
{
    return us_crc16(init, p_data, length, 0x1021, false, 0x0);
}

/***********************************************************************************************************************
 * 函数功能    : CRC16 计算 (Poly = 0x8005)
 * 说明(备注)  : LSB 模式
 * 传入参数    : init: 初始值; p_data: 待校验数据指针; length: 待校验长度
 * 输出参数    : 无
 * 返回值      : CRC16 校验值
 ************************************************************************************************************************/
uint16_t usCheck_Crc16(uint16_t init, const uint8_t *p_data, uint16_t length)
{
    return us_crc16(init, p_data, length, 0x8005, true, 0x0);
}

/***********************************************************************************************************************
 * 函数功能    : Modbus-CRC16 计算法
 * 说明(备注)  : 初始值 0xFFFF，低位在后
 * 传入参数    : p_data: 待校验数据指针; len: 待校验长度
 * 输出参数    : 无
 * 返回值      : 16位 Modbus CRC 结果
 ************************************************************************************************************************/
uint16_t usCheck_GetModbusCrc16(const uint8_t *p_data, uint32_t len)
{
    uint8_t  uc_temp;
    uint16_t us_wcrc = 0xFFFF;

    if (p_data == NULL)
        return 0;

    for (uint32_t i = 0; i < len; i++)
    {
        uc_temp = p_data[i] & 0x00FF;
        us_wcrc ^= uc_temp;
        for (uint32_t j = 0; j < 8; j++)
        {
            if (us_wcrc & 0x0001)
            {
                us_wcrc >>= 1;
                us_wcrc ^= 0xA001;
            }
            else
                us_wcrc >>= 1;
        }
    }

    return us_wcrc;
}

/***********************************************************************************************************************
 * 函数功能    : CRC16 MSB 查表法快速计算
 * 说明(备注)  : 使用 Flash 常量表，零栈消耗
 * 传入参数    : p_buf: 待校验数据指针; len: 长度; crc: 初始 CRC 状态
 * 输出参数    : 无
 * 返回值      : 计算后的 CRC16 值
 ************************************************************************************************************************/
uint16_t usCheck_MsbDataGetCrc16(const uint8_t *p_buf, int len, uint16_t crc)
{
    if (p_buf == NULL || len <= 0)
        return crc;

    for (int i = 0; i < len; i++)
        crc = S_usaCrc16MsbTable[((crc >> 8) ^ p_buf[i]) & 0xFF] ^ (crc << 8);

    return crc;
}

/***********************************************************************************************************************
 * 函数功能    : CRC16 LSB 查表法快速计算
 * 说明(备注)  : 使用 Flash 常量表，零栈消耗
 * 传入参数    : p_buf: 待校验数据指针; len: 长度; crc: 初始 CRC 状态
 * 输出参数    : 无
 * 返回值      : 计算后的 CRC16 值
 ************************************************************************************************************************/
uint16_t usCheck_LsbDataGetCrc16(const unsigned char *p_buf, int len, uint16_t crc)
{
    if (p_buf == NULL || len <= 0)
        return crc;

    for (int i = 0; i < len; i++)
        crc = S_usaCrc16LsbTable[((crc) ^ p_buf[i]) & 0xFF] ^ (crc >> 8);

    return crc;
}

/***********************************************************************************************************************
 * 函数功能    : 查表法计算 Modbus-CRC16
 * 说明(备注)  : Modbus 双表快速查表法，高位在前
 * 传入参数    : p_msg: 消息缓冲区首地址; us_data_len: 消息长度
 * 输出参数    : 无
 * 返回值      : 16位 CRC 校验码
 ************************************************************************************************************************/
uint16_t usCheck_CRC16(const uint8_t *p_msg, uint16_t us_data_len)
{
    uint8_t uc_crc_hi = 0xFF;
    uint8_t uc_crc_lo = 0xFF;
    uint8_t s_uca_index;

    if (p_msg == NULL)
        return 0;

    while (us_data_len--)
    {
        s_uca_index  = uc_crc_hi ^ *p_msg++;
        uc_crc_hi = uc_crc_lo ^ S_ucaCrcHi[s_uca_index];
        uc_crc_lo = S_ucaCrcLo[s_uca_index];
    }

    return (uint16_t)((uc_crc_lo << 8) | uc_crc_hi);
}

/***********************************************************************************************************************
 * 函数功能    : CRC16查表法计算（用于XModem校验）
 * 说明(备注)  : X16+X15+X2+X1 多项式查表计算
 * 传入参数    : p_buf: 数据指针; len: 数据长度
 * 输出参数    : 无
 * 返回值      : 16位 CRC 校验码
 ************************************************************************************************************************/
uint16_t usCheck_GetCrc16Tab(const uint8_t *p_buf, uint16_t len)
{
    uint16_t us_result = 0;
    uint16_t us_table_no = 0;

    if (p_buf == NULL)
        return 0;

    for (uint16_t i = 0; i < len; i++)
    {
        us_table_no = ((us_result & 0xFF) ^ (p_buf[i] & 0xFF));
        us_result   = ((us_result >> 8) & 0xFF) ^ S_usaCrc16LsbTable[us_table_no];
    }

    return us_result;
}

/***********************************************************************************************************************
 * 函数功能    : 通用 CRC32 计算核心
 * 说明(备注)  : 内部静态函数 (Poly = 0x04C11DB7)
 * 传入参数    : init: 初始值; p_data: 数据指针; len: 长度; reflection: 反转标志; final_xor: 异或掩码
 * 输出参数    : 无
 * 返回值      : CRC32 结果
 ************************************************************************************************************************/
static uint32_t ul_crc32(uint32_t init, const uint8_t *p_data, uint32_t len, bool reflection, uint32_t final_xor)
{
    const uint32_t ul_polynomial = 0x04C11DB7;
    uint32_t ul_xbit;
    uint32_t ul_data;
    uint32_t ul_crc_cnt = init;

    if (p_data == NULL && len > 0)
        return (init ^ final_xor);

    for (uint32_t i = 0; i < len; i++)
    {
        ul_xbit = 0x80;
        ul_data = p_data[i];
        if (reflection)
            ul_data = (uint32_t)ul_data_reflect(ul_data, 8);

        for (int bits = 0; bits < 8; bits++)
        {
            if ((ul_crc_cnt & 0x80000000) > 0)
            {
                ul_crc_cnt <<= 1;
                ul_crc_cnt ^= ul_polynomial;
            }
            else
                ul_crc_cnt <<= 1;

            if ((ul_data & ul_xbit) > 0)
                ul_crc_cnt ^= ul_polynomial;

            ul_xbit >>= 1;
        }
    }

    if (reflection)
        ul_crc_cnt = (uint32_t)ul_data_reflect(ul_crc_cnt, 32);

    ul_crc_cnt ^= final_xor;
    return ul_crc_cnt;
}

/***********************************************************************************************************************
 * 函数功能    : 获取 CRC32 校验码 (IEEE 802.3 标准)
 * 说明(备注)  : 反射模式，结果异或 0xFFFFFFFF
 * 传入参数    : init: 初始值; p_data: 数据指针; length: 数据长度
 * 输出参数    : 无
 * 返回值      : 32位 CRC 校验结果
 ************************************************************************************************************************/
uint32_t ulCheck_GetCRC32(uint32_t init, const uint8_t *p_data, uint32_t length)
{
    return ul_crc32(init, p_data, length, true, 0xFFFFFFFF);
}

/***********************************************************************************************************************
 * 函数功能    : CRC32 增量更新计算 (位反转 / LSB 模式)
 * 说明(备注)  : 按字节逐位计算 CRC32，多项式 0xEDB88320。增量式计算，最终需外部异或 0xFFFFFFFF 取反
 * 传入参数    : crc_state: 当前 CRC 状态 (初始应为 0xFFFFFFFF); p_data: 数据指针; len: 数据长度
 * 输出参数    : 无
 * 返回值      : 更新后的 CRC32 状态值
 ************************************************************************************************************************/
u32 ulCheck_Crc32Update(u32 crc_state, const u8 *p_data, u16 len)
{
    if (p_data == NULL)
        return crc_state;

    for (u16 i = 0; i < len; i++)
    {
        crc_state ^= p_data[i];
        for (u8 bit = 0; bit < 8; bit++)
        {
            if (crc_state & 0x00000001UL)
                crc_state = (crc_state >> 1) ^ 0xEDB88320UL;
            else
                crc_state >>= 1;
        }
    }

    return crc_state;
}

#endif  /* 1 */
