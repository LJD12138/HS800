#include "check.h"
#include "function.h"

/*******************************************************
 *                Variables Declarations
 *******************************************************/
//CRC8 X8+X5+X4+1查询表
static const uint8_t crc8541_table[] ={
    0x00,0x31,0x62,0x53,0xc4,0xf5,0xa6,0x97,0xb9,0x88,0xdb,0xea,0x7d,0x4c,0x1f,0x2e,\
    0x43,0x72,0x21,0x10,0x87,0xb6,0xe5,0xd4,0xfa,0xcb,0x98,0xa9,0x3e,0x0f,0x5c,0x6d,\
    0x86,0xb7,0xe4,0xd5,0x42,0x73,0x20,0x11,0x3f,0x0e,0x5d,0x6c,0xfb,0xca,0x99,0xa8,\
    0xc5,0xf4,0xa7,0x96,0x01,0x30,0x63,0x52,0x7c,0x4d,0x1e,0x2f,0xb8,0x89,0xda,0xeb,\
    0x3d,0x0c,0x5f,0x6e,0xf9,0xc8,0x9b,0xaa,0x84,0xb5,0xe6,0xd7,0x40,0x71,0x22,0x13,\
    0x7e,0x4f,0x1c,0x2d,0xba,0x8b,0xd8,0xe9,0xc7,0xf6,0xa5,0x94,0x03,0x32,0x61,0x50,\
    0xbb,0x8a,0xd9,0xe8,0x7f,0x4e,0x1d,0x2c,0x02,0x33,0x60,0x51,0xc6,0xf7,0xa4,0x95,\
    0xf8,0xc9,0x9a,0xab,0x3c,0x0d,0x5e,0x6f,0x41,0x70,0x23,0x12,0x85,0xb4,0xe7,0xd6,\
    0x7a,0x4b,0x18,0x29,0xbe,0x8f,0xdc,0xed,0xc3,0xf2,0xa1,0x90,0x07,0x36,0x65,0x54,\
    0x39,0x08,0x5b,0x6a,0xfd,0xcc,0x9f,0xae,0x80,0xb1,0xe2,0xd3,0x44,0x75,0x26,0x17,\
    0xfc,0xcd,0x9e,0xaf,0x38,0x09,0x5a,0x6b,0x45,0x74,0x27,0x16,0x81,0xb0,0xe3,0xd2,\
    0xbf,0x8e,0xdd,0xec,0x7b,0x4a,0x19,0x28,0x06,0x37,0x64,0x55,0xc2,0xf3,0xa0,0x91,\
    0x47,0x76,0x25,0x14,0x83,0xb2,0xe1,0xd0,0xfe,0xcf,0x9c,0xad,0x3a,0x0b,0x58,0x69,\
    0x04,0x35,0x66,0x57,0xc0,0xf1,0xa2,0x93,0xbd,0x8c,0xdf,0xee,0x79,0x48,0x1b,0x2a,\
    0xc1,0xf0,0xa3,0x92,0x05,0x34,0x67,0x56,0x78,0x49,0x1a,0x2b,0xbc,0x8d,0xde,0xef,\
    0x82,0xb3,0xe0,0xd1,0x46,0x77,0x24,0x15,0x3b,0x0a,0x59,0x68,0xff,0xce,0x9d,0xac
};


const uint8_t  CRC8Table[]=
{							//120424-1			CRC Table
	0x00,0x07,0x0E,0x09,0x1C,0x1B,0x12,0x15,0x38,0x3F,0x36,0x31,0x24,0x23,0x2A,0x2D,
	0x70,0x77,0x7E,0x79,0x6C,0x6B,0x62,0x65,0x48,0x4F,0x46,0x41,0x54,0x53,0x5A,0x5D,
	0xE0,0xE7,0xEE,0xE9,0xFC,0xFB,0xF2,0xF5,0xD8,0xDF,0xD6,0xD1,0xC4,0xC3,0xCA,0xCD,
	0x90,0x97,0x9E,0x99,0x8C,0x8B,0x82,0x85,0xA8,0xAF,0xA6,0xA1,0xB4,0xB3,0xBA,0xBD,
	0xC7,0xC0,0xC9,0xCE,0xDB,0xDC,0xD5,0xD2,0xFF,0xF8,0xF1,0xF6,0xE3,0xE4,0xED,0xEA,
	0xB7,0xB0,0xB9,0xBE,0xAB,0xAC,0xA5,0xA2,0x8F,0x88,0x81,0x86,0x93,0x94,0x9D,0x9A,
	0x27,0x20,0x29,0x2E,0x3B,0x3C,0x35,0x32,0x1F,0x18,0x11,0x16,0x03,0x04,0x0D,0x0A,
	0x57,0x50,0x59,0x5E,0x4B,0x4C,0x45,0x42,0x6F,0x68,0x61,0x66,0x73,0x74,0x7D,0x7A,
	0x89,0x8E,0x87,0x80,0x95,0x92,0x9B,0x9C,0xB1,0xB6,0xBF,0xB8,0xAD,0xAA,0xA3,0xA4,
	0xF9,0xFE,0xF7,0xF0,0xE5,0xE2,0xEB,0xEC,0xC1,0xC6,0xCF,0xC8,0xDD,0xDA,0xD3,0xD4,
	0x69,0x6E,0x67,0x60,0x75,0x72,0x7B,0x7C,0x51,0x56,0x5F,0x58,0x4D,0x4A,0x43,0x44,
	0x19,0x1E,0x17,0x10,0x05,0x02,0x0B,0x0C,0x21,0x26,0x2F,0x28,0x3D,0x3A,0x33,0x34,
	0x4E,0x49,0x40,0x47,0x52,0x55,0x5C,0x5B,0x76,0x71,0x78,0x7F,0x6A,0x6D,0x64,0x63,
	0x3E,0x39,0x30,0x37,0x22,0x25,0x2C,0x2B,0x06,0x01,0x08,0x0F,0x1A,0x1D,0x14,0x13,
	0xAE,0xA9,0xA0,0xA7,0xB2,0xB5,0xBC,0xBB,0x96,0x91,0x98,0x9F,0x8A,0x8D,0x84,0x83,
	0xDE,0xD9,0xD0,0xD7,0xC2,0xC5,0xCC,0xCB,0xE6,0xE1,0xE8,0xEF,0xFA,0xFD,0xF4,0xF3
};



//CRC16 X16+X15+X2+X1
static const uint16_t crc161521[256] = {
    0x0000, 0xC0C1, 0xC181, 0x0140, 0xC301, 0x03C0, 0x0280, 0xC241,
    0xC601, 0x06C0, 0x0780, 0xC741, 0x0500, 0xC5C1, 0xC481, 0x0440,
    0xCC01, 0x0CC0, 0x0D80, 0xCD41, 0x0F00, 0xCFC1, 0xCE81, 0x0E40,
    0x0A00, 0xCAC1, 0xCB81, 0x0B40, 0xC901, 0x09C0, 0x0880, 0xC841,
    0xD801, 0x18C0, 0x1980, 0xD941, 0x1B00, 0xDBC1, 0xDA81, 0x1A40,
    0x1E00, 0xDEC1, 0xDF81, 0x1F40, 0xDD01, 0x1DC0, 0x1C80, 0xDC41,
    0x1400, 0xD4C1, 0xD581, 0x1540, 0xD701, 0x17C0, 0x1680, 0xD641,
    0xD201, 0x12C0, 0x1380, 0xD341, 0x1100, 0xD1C1, 0xD081, 0x1040,
    0xF001, 0x30C0, 0x3180, 0xF141, 0x3300, 0xF3C1, 0xF281, 0x3240,
    0x3600, 0xF6C1, 0xF781, 0x3740, 0xF501, 0x35C0, 0x3480, 0xF441,
    0x3C00, 0xFCC1, 0xFD81, 0x3D40, 0xFF01, 0x3FC0, 0x3E80, 0xFE41,
    0xFA01, 0x3AC0, 0x3B80, 0xFB41, 0x3900, 0xF9C1, 0xF881, 0x3840,
    0x2800, 0xE8C1, 0xE981, 0x2940, 0xEB01, 0x2BC0, 0x2A80, 0xEA41,
    0xEE01, 0x2EC0, 0x2F80, 0xEF41, 0x2D00, 0xEDC1, 0xEC81, 0x2C40,
    0xE401, 0x24C0, 0x2580, 0xE541, 0x2700, 0xE7C1, 0xE681, 0x2640,
    0x2200, 0xE2C1, 0xE381, 0x2340, 0xE101, 0x21C0, 0x2080, 0xE041,
    0xA001, 0x60C0, 0x6180, 0xA141, 0x6300, 0xA3C1, 0xA281, 0x6240,
    0x6600, 0xA6C1, 0xA781, 0x6740, 0xA501, 0x65C0, 0x6480, 0xA441,
    0x6C00, 0xACC1, 0xAD81, 0x6D40, 0xAF01, 0x6FC0, 0x6E80, 0xAE41,
    0xAA01, 0x6AC0, 0x6B80, 0xAB41, 0x6900, 0xA9C1, 0xA881, 0x6840,
    0x7800, 0xB8C1, 0xB981, 0x7940, 0xBB01, 0x7BC0, 0x7A80, 0xBA41,
    0xBE01, 0x7EC0, 0x7F80, 0xBF41, 0x7D00, 0xBDC1, 0xBC81, 0x7C40,
    0xB401, 0x74C0, 0x7580, 0xB541, 0x7700, 0xB7C1, 0xB681, 0x7640,
    0x7200, 0xB2C1, 0xB381, 0x7340, 0xB101, 0x71C0, 0x7080, 0xB041,
    0x5000, 0x90C1, 0x9181, 0x5140, 0x9301, 0x53C0, 0x5280, 0x9241,
    0x9601, 0x56C0, 0x5780, 0x9741, 0x5500, 0x95C1, 0x9481, 0x5440,
    0x9C01, 0x5CC0, 0x5D80, 0x9D41, 0x5F00, 0x9FC1, 0x9E81, 0x5E40,
    0x5A00, 0x9AC1, 0x9B81, 0x5B40, 0x9901, 0x59C0, 0x5880, 0x9841,
    0x8801, 0x48C0, 0x4980, 0x8941, 0x4B00, 0x8BC1, 0x8A81, 0x4A40,
    0x4E00, 0x8EC1, 0x8F81, 0x4F40, 0x8D01, 0x4DC0, 0x4C80, 0x8C41,
    0x4400, 0x84C1, 0x8581, 0x4540, 0x8701, 0x47C0, 0x4680, 0x8641,
    0x8201, 0x42C0, 0x4380, 0x8341, 0x4100, 0x81C1, 0x8081, 0x4040
};


/* CRC 高位字节值表 */ 
const  uint8_t auchCRCHi[] = 
{ 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
	0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
	0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 
	0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40 
};

/* CRC低位字节值表*/ 
const  uint8_t auchCRCLo[] = 
{ 
	0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 
	0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 
	0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 
	0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 
	0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4, 
	0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3, 
	0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 
	0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 
	0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 
	0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 
	0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED, 
	0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26, 
	0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 
	0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 
	0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 
	0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 
	0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 
	0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5, 
	0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 
	0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 
	0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 
	0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 
	0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B, 
	0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C, 
	0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 
	0x43, 0x83, 0x41, 0x81, 0x80, 0x40 
};





/************************************************************************
	\brief      数据bit反转,MSB和LSB数据调换
	\param[in]  input:需要反转的数据
				bits:从bit0开始,需要反转多少个bit
	\param[out] none
	\retval     CRC8的值
************************************************************************/
static uint32_t ul_data_reflect(uint32_t input, uint8_t bits)
{
    uint32_t result = 0;
    for (uint8_t i = 0; i < bits; i++)
    {
        uint32_t bit = (uint32_t)((input >> i) & 1);
        bit = (uint32_t)(bit << (bits - 1 - i));
        result |= bit;
    }
    return result;
}



///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
/*****************************************************************累加和***************************************************************************/
///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
/************************************************************************
	\brief      累加和校验取反
    \param[in]  str需要校验数据的指针, str_length需要校验的长度
	\param[out] none
	\retval     CRC8的值
************************************************************************/
uint8_t ucCheck_SumReflect(uint8_t *str, int str_length)
{
    uint8_t CheckSum_Value = 0;
    int i = 0;
    for(i = 0; i < str_length; i++)
    {
       CheckSum_Value += str[i];
    }
    return ((~CheckSum_Value) + 1);
}

/************************************************************************
	\brief      累加和校验
    \param[in]  str需要校验数据的指针, str_length需要校验的长度
	\param[out] none
	\retval     CRC8的值
************************************************************************/
uint8_t ucCheck_Sum(uint8_t *str, int str_length)
{
    uint8_t CheckSum_Value = 0;
    int i = 0;
    for(i = 0; i < str_length; i++)
    {
       CheckSum_Value += str[i];
    }
    return CheckSum_Value;
}


///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
/*****************************************************************CRC8****************************************************************************/
///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

/************************************************************************
	\brief      CRC8查表法(X8+X5+X4+1)
    \param[in]  buf需要校验数据的指针, len需要校验的长度
	\param[out] none
	\retval     CRC8的值
************************************************************************/
uint8_t ucCheck_GetCrc8Tab(uint8_t *buf, uint16_t len)
{
    uint8_t crc = 0x00;
    while (len--)
        crc = crc8541_table[crc ^ *buf++];
    return crc;
}


/*******************************************************************************
Function: CRC8cal()
Description:
In: 
Output: 
********************************************************************************/
uint8_t ucCheck_CRC8cal(uint8_t *p, uint8_t counter)    		   //look-up table calculte CRC 
{    
    uint8_t crc8 = 0;    
    
	for( ; counter > 0; counter--)
	{	
		crc8 = CRC8Table[crc8^(*p)];    
	    p++;    
    }    
    return(crc8);    
}




/**********************************************************************************************************
	\brief      CRC8计算法
	\param[in]  init:CRC初始值
				data:输入要校验的字节数组。
				len:需要校验的长度
				poly:Poly值，如果是CRC8，那么就是0x8005，如果是CRC-CCITT，那么就是0x1201,这些值网上可以查到。
					 CRC-8       x8+x5+x4+1              poly = 0x31（0x131）
					 CRC-8       x8+x2+x1+1              poly = 0x07（0x107）
					 CRC-8       x8+x6+x4+x3+x2+x1       poly = 0x5E（0x15E）
				reflection： true--LSB模式、 FALSE---MSB模式。
	\param[out] none
	\retval     CRC8的值
***********************************************************************************************************/
uint8_t ucCheck_GetCrc8(uint8_t init, const uint8_t *data, uint16_t length, uint8_t poly, bool reflection)
{
	unsigned char i;
	unsigned char crc = init; /* 计算的初始crc值 */
	unsigned char tmp = 0;

	while (length--)
	{
		tmp = *data++;/* 每次先与需要计算的数据异或,计算完指向下一数据 */
		if (reflection)				//是否LSB
			tmp = (uint8_t)ul_data_reflect(tmp, 8);
		crc ^= tmp;
		for (i = 8; i > 0; --i)   /* 下面这段计算过程与计算一个字节crc一样 */
		{
			if (crc & 0x80)
				crc = (crc << 1) ^ poly;
			else
				crc = (crc << 1);
		}
	}
	if (reflection)
		crc = (uint8_t)ul_data_reflect(crc, 8);
	return crc;
}


///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
/*****************************************************************CRC16***************************************************************************/
///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

/**********************************************************************************************************
	\brief      CRC16计算法
	\param[in]  init:CRC初始值
				data:输入要校验的字节数组。
				length:需要校验的长度
				Poly值，如果是CRC16，那么就是0x8005，如果是CRC-CCITT，那么就是0x1201,这些值网上可以查到。
				reflection:true--LSB模式、 FALSE---MSB模式。
				final_xor:输出值与之异或
	\param[out] none
	\retval     CRC8的值
***********************************************************************************************************/
static uint16_t usCheck_crc16(uint16_t init, const uint8_t* data, uint16_t length, uint16_t poly, bool reflection, uint16_t final_xor)
{
    uint16_t crc = init;        //初始值
    uint32_t start = 0;

    while (length-- > 0)
    {
        uint8_t bt = data[start++];
        if (reflection)                         //LSB
            bt = (uint8_t)ul_data_reflect(bt, 8);
        for (int i = 0; i < 8; i++)
        {
            bool msb_crc = (bool)((crc & 0x8000U) != 0);
            bool msb_data = (bool)((bt & 0x80U) != 0);
            if (msb_crc != msb_data) 
                crc = (uint16_t)((crc << 1) ^ poly);
            else 
                crc <<= 1;
            bt <<= 1;
        }
    }
    if (reflection)
        crc = (uint16_t)ul_data_reflect(crc, 16);
    crc ^= final_xor;
    return crc;
}



/********************************************************************************
	\brief      CRC16计算法
    \param[in]  data需要校验数据的指针
                len需要校验的长度
	\param[out] none
	\retval     CRC16的值
********************************************************************************/
uint16_t usCheck_CRC_CCITT(uint16_t init,  const uint8_t* data, uint16_t length)
{
    return usCheck_crc16(init, data, length, 0x1021, false, 0x0);
}

/********************************************************************************
	\brief      CRC16计算法
    \param[in]  data需要校验数据的指针
                len需要校验的长度
	\param[out] none
	\retval     CRC16的值
********************************************************************************/
uint16_t usCheck_Crc16(uint16_t init, uint8_t* data, uint16_t length)
{
    return usCheck_crc16(init, data, length, 0x8005, true, 0x0);
}



/********************************************************************************
	\brief      CRC16计算法 Modbus-CRC校验 这个应该是和usCheck_LsbDataGetCrc16一样
    \param[in]  data需要校验数据的指针
                len需要校验的长度
	\param[out] none
	\retval     CRC16的值
********************************************************************************/
uint16_t usCheck_GetModbusCrc16(uint8_t *data, uint32_t len)
{
	uint8_t temp;
	uint16_t wcrc = 0XFFFF;//16位crc寄存器预置
	uint32_t i = 0, j = 0;//计数
	for (i = 0; i < len; i++)//循环计算每个数据
	{
		temp = data[i] & 0X00FF;//将八位数据与crc寄存器亦或
		wcrc ^= temp;						//将数据存入crc寄存器
		for (j = 0; j < 8; j++)	//循环计算数据的
		{
			if (wcrc & 0X0001)//判断右移出的是不是1，如果是1则与多项式进行异或。
			{
				wcrc >>= 1;//先将数据右移一位
				wcrc ^= 0XA001;//与上面的多项式进行异或
			}
			else//如果不是1，则直接移出
			{
				wcrc >>= 1;//直接移出
			}
		}
	}
	return wcrc;
//  return ((wcrc>>8)|(wcrc << 8));//高低位置换
}


/************************************************************************
	\brief      CRC16计算法(X16+X15+X2+X1)  
    \param[in]  buf(MSB)需要校验数据的指针,buff [high bit...low bit]; 
                len需要校验的长度
	\param[out] none
	\retval     CRC16的值
************************************************************************/
static uint16_t crc16(uint8_t data, uint16_t crc) 
{
	uint16_t ccitt16 = 0x8005;
	int i;
	crc ^= (data<<8);
	for (i=0; i<8; i++)
	{
		if (crc & 0x8000)
		{
		   crc <<= 1;
		   crc ^= ccitt16;
		}
		else
		{
		   crc <<= 1;
		}
	}
	return crc;
}
uint16_t usCheck_MsbDataGetCrc16(uint8_t* buf, int len, uint16_t crc)
{
    uint16_t crc16_table[256];
	for(unsigned int i=0; i<256; i++)
	{
		crc16_table[i] = crc16(i, 0);
	}
	for(unsigned int i=0; i<len; i++)
	{
		crc = crc16_table[((crc>>8)^buf[i])&0xff]^(crc<<8);	
	}
	return crc;
}

/************************************************************************
	\brief      CRC16计算法(X16+X15+X2+X1)  
    \param[in]  buf(LSB)需要校验数据的指针, ,buff [ low bit...high bit];
				len需要校验的长度
	\param[out] none
	\retval     CRC16的值
************************************************************************/
static uint16_t crc16_r(uint8_t data, uint16_t crc)
{
	uint16_t ccitt16 = 0xa001;    //(0x8005->[reverse]->0xa001)
	int i;
	crc ^= data;
	for (i=0; i<8; i++)
	{
		if (crc & 1)
		{
		   crc >>= 1;
		   crc ^= ccitt16;
		}
		else
		{
		   crc >>= 1;
		}
	}
	return crc;
}
uint16_t usCheck_LsbDataGetCrc16(unsigned char* buf, int len, uint16_t crc)
{
    uint16_t crc16_table_r[256];
	for(unsigned int i=0; i<256; i++)
	{
		crc16_table_r[i] = crc16_r(i, 0);
	}
	for(unsigned int i=0; i<len; i++)
	{
		crc = crc16_table_r[((crc)^buf[i])&0xff]^(crc>>8);	
	}
	return crc;
}

/********************************************************************************
	\brief      
    \param[in]  buf需要校验数据的指针
                len需要校验的长度
	\param[out] none
	\retval     CRC16的值
********************************************************************************/
uint16_t usCheck_CRC16(uint8_t *puchMsg, uint8_t usDataLen) 
{ 
	uint8_t uchCRCHi = 0xFF ;              // 高CRC字节初始化  
	uint8_t uchCRCLo = 0xFF ;              // 低CRC 字节初始化 

	uint8_t uIndex ;                      // CRC循环中的索引   
	
	while (usDataLen--)                  // 传输消息缓冲区  
	{ 
		uIndex = uchCRCHi ^ *puchMsg++ ; // 计算CRC         
		uchCRCHi = uchCRCLo ^ auchCRCHi[uIndex]; 
		uchCRCLo = auchCRCLo[uIndex]; 
	} 

	return (uchCRCLo << 8 | uchCRCHi);	// MODBUS 规定高位在前
}


/************************************************************************
	\brief      CRC16查表法(X16+X15+X2+X1),用于XModem的校验方式
    \param[in]  buf需要校验数据的指针, len需要校验的长度
	\param[out] none
	\retval     CRC16的值
************************************************************************/
uint16_t usCheck_GetCrc16Tab(uint8_t *buf, uint16_t len)
{  
    uint16_t result  = 0;
    uint16_t tableNo = 0;
    for(uint16_t i = 0; i < len; i++)
    {
        tableNo = ((result & 0xff) ^ (buf[i] & 0xff));
        result  = ((result >> 8) & 0xff) ^ crc161521[tableNo];
    }
    return result;
}

///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
/*****************************************************************CRC32***************************************************************************/
///////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

/*******************************************************************************************************************
	\brief      CRC32校验
	\param[in]  CRCinit:CRC初始值
				InData：  输入要校验的字节数组。
				len:数据的长度
				reflection： ture--LSB模式、 false---MSB模式。
				final_xor：  输出值与之异或
	\param[out] none
	\retval     CRC16的值
*******************************************************************************************************************/
static uint32_t crc32(uint32_t CRCinit, const uint8_t* InData, uint32_t len, bool reflection, uint32_t final_xor)
{
    uint32_t dwPolynomial = 0x04c11db7;

    uint32_t xbit;
    uint32_t data;
    uint32_t crc_cnt = CRCinit; 
    
    for (uint32_t i = 0; i < len; i++)
    {
        xbit = 0x80;
        data = InData[i];
        if (reflection)         //true
            data = (uint32_t)ul_data_reflect(data, 8);

        for (int bits = 0; bits < 8; bits++)
        {
            if ((crc_cnt & 0x80000000) > 0)
            {
                crc_cnt <<= 1;
                crc_cnt ^= dwPolynomial;
            }
            else
                crc_cnt <<= 1;

            if ((data & xbit) > 0)
                crc_cnt ^= dwPolynomial;
            xbit >>= 1;
        }
    }
    if (reflection)
        crc_cnt = (uint32_t)ul_data_reflect(crc_cnt, 32);
    crc_cnt ^= final_xor;   //final_xor = 0xFFFFFFFFF
    return crc_cnt;
}
uint32_t ulCheck_GetCRC32(uint32_t init, uint8_t* data, uint32_t length)
{
    return crc32(init, data, length, true, 0xFFFFFFFF);
}









