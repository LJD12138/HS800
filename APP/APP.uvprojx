# Keil uVision project APP.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: $PMergeTool.bat $K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\Firmware\CMSIS;.\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;.\Middlewares\FreeRTOS\include;.\Middlewares\SeggerRtt;.\ComFunc;.\Application;.\Hardware;.\Hardware\BSP;.\Middlewares\CmBacktrace;.\Middlewares\CmBacktrace\Languages\zh-CN;.\Middlewares\LightweightRingBuffer\src;.\Middlewares\EasyLogger\inc;.\Middlewares\EasyLogger\plugins\flash;.\Middlewares\EasyFlash\inc;.\Middlewares\Protocol;.\Middlewares\LVGL;.\Middlewares\LVGL\src
  library: MicroLIB
  memory RVCT4: ROM 0x800d000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group MW-FreeRTOS
    ./Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group MW-EasyFlash
    ./Middlewares/EasyFlash/src/: easyflash.c ef_env.c ef_iap.c ef_log.c ef_utils.c
    ./Middlewares/EasyFlash/port/: ef_port.c
  group MW-EasyLogger
    ./Middlewares/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_Init.c elog_utils.c
    ./Middlewares/EasyLogger/port/: elog_port.c
    ./Middlewares/EasyLogger/plugins/flash/: elog_flash.c elog_flash_port.c
  group MW-CmBacktrace
    ./Middlewares/CmBacktrace/: cm_backtrace.c
    ./Middlewares/CmBacktrace/fault_handler/keil/: cmb_fault.S
  group MW-SeggerRtt
    ./Middlewares/SeggerRtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group MW-Protocol
    ./Middlewares/Protocol/Modbus/: modbus_proto.c modbus_proto.h
    ./Middlewares/Protocol/BaiKu/: baiku_proto.c baiku_proto.h
    ./Middlewares/Protocol/: proto_updata.c proto_updata.h
    ./Middlewares/Protocol/Modbus1/: modbus_proto1.c modbus_proto1.h
  group MW-LVGL
    .//Middlewares//LVGL//src//core//: lv_global.h lv_group.c lv_group.h lv_group_private.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_class_private.h lv_obj_draw.c lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.c lv_obj_event.h lv_obj_event_private.h lv_obj_id_builtin.c lv_obj_pos.c lv_obj_pos.h lv_obj_private.h lv_obj_property.c lv_obj_property.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_refr_private.h
    .//Middlewares//LVGL//src//display//: lv_display.c lv_display.h lv_display_private.h
    .//Middlewares//LVGL//src//draw//convert//helium//: lv_draw_buf_convert_helium.c lv_draw_buf_convert_helium.h
    .//Middlewares//LVGL//src//draw//convert//neon//: lv_draw_buf_convert_neon.c lv_draw_buf_convert_neon.h
    .//Middlewares//LVGL//src//draw//convert//: lv_draw_buf_convert.c lv_draw_buf_convert.h
    .//Middlewares//LVGL//src//draw//dma2d//: lv_draw_dma2d.c lv_draw_dma2d.h lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d_private.h
    .//Middlewares//LVGL//src//draw//espressif//ppa//: lv_draw_ppa.c lv_draw_ppa.h lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c lv_draw_ppa_private.h
    .//Middlewares//LVGL//src//draw//eve//: lv_draw_eve.c lv_draw_eve.h lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_private.h lv_draw_eve_ram_g.c lv_draw_eve_ram_g.h lv_draw_eve_target.h lv_draw_eve_triangle.c lv_eve.c lv_eve.h
    .//Middlewares//LVGL//src//draw//nema_gfx//: lv_draw_nema_gfx.c lv_draw_nema_gfx.h lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_utils.h lv_nema_gfx_path.c lv_nema_gfx_path.h
    .//Middlewares//LVGL//src//draw//nxp//g2d//: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d.h lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_buf_map.h lv_g2d_utils.c lv_g2d_utils.h
    .//Middlewares//LVGL//src//draw//nxp//pxp//: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_cfg.h lv_pxp_osa.c lv_pxp_osa.h lv_pxp_utils.c lv_pxp_utils.h
    .//Middlewares//LVGL//src//draw//nxp//vglite//: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_buf.h lv_vglite_matrix.c lv_vglite_matrix.h lv_vglite_path.c lv_vglite_path.h lv_vglite_utils.c lv_vglite_utils.h
    .//Middlewares//LVGL//src//draw//opengles//: lv_draw_opengles.c lv_draw_opengles.h
    .//Middlewares//LVGL//src//draw//renesas//dave2d//: lv_draw_dave2d.c lv_draw_dave2d.h lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d_utils.h
    .//Middlewares//LVGL//src//draw//sdl//: lv_draw_sdl.c lv_draw_sdl.h
    .//Middlewares//LVGL//src//draw//sw//arm2d//: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
    .//Middlewares//LVGL//src//draw//sw//blend//arm2d//: lv_blend_arm2d.h
    .//Middlewares//LVGL//src//draw//sw//blend//helium//: lv_blend_helium.h
    .//Middlewares//LVGL//src//draw//sw//blend//neon//: lv_blend_neon.h lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb565.h
    .//Middlewares//LVGL//src//draw//sw//blend//: lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888_premultiplied.h lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565_swapped.h lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb888.h
    .//Middlewares//LVGL//src//draw//sw//: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_grad.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_mask_rect.c lv_draw_sw_private.h lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_utils.h lv_draw_sw_vector.c
    .//Middlewares//LVGL//src//draw//vg_lite//: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite.h lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_type.h lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_decoder.h lv_vg_lite_grad.c lv_vg_lite_grad.h lv_vg_lite_math.c lv_vg_lite_math.h lv_vg_lite_path.c lv_vg_lite_path.h lv_vg_lite_pending.c lv_vg_lite_pending.h lv_vg_lite_stroke.c lv_vg_lite_stroke.h lv_vg_lite_utils.c lv_vg_lite_utils.h
    .//Middlewares//LVGL//src//draw//: lv_draw.c lv_draw.h lv_draw_3d.c lv_draw_3d.h lv_draw_arc.c lv_draw_arc.h lv_draw_buf.c lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.c lv_draw_image.h lv_draw_image_private.h lv_draw_label.c lv_draw_label.h lv_draw_label_private.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_mask_private.h lv_draw_private.h lv_draw_rect.c lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.c lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.c lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
    .//Middlewares//LVGL//src//drivers//display//drm//: lv_linux_drm.c lv_linux_drm.h
    .//Middlewares//LVGL//src//drivers//display//fb//: lv_linux_fbdev.c lv_linux_fbdev.h
    .//Middlewares//LVGL//src//drivers//display//ft81x//: lv_ft81x.c lv_ft81x.h lv_ft81x_defines.h
    .//Middlewares//LVGL//src//drivers//display//ili9341//: lv_ili9341.c lv_ili9341.h
    .//Middlewares//LVGL//src//drivers//display//lcd//: lv_lcd_generic_mipi.c lv_lcd_generic_mipi.h
    .//Middlewares//LVGL//src//drivers//display//lovyan_gfx//: lv_lovyan_gfx.h
    .//Middlewares//LVGL//src//drivers//display//nxp_elcdif//: lv_nxp_elcdif.c lv_nxp_elcdif.h
    .//Middlewares//LVGL//src//drivers//display//renesas_glcdc//: lv_renesas_glcdc.c lv_renesas_glcdc.h
    .//Middlewares//LVGL//src//drivers//display//st7735//: lv_st7735.c lv_st7735.h
    .//Middlewares//LVGL//src//drivers//display//st7789//: lv_st7789.c lv_st7789.h
    .//Middlewares//LVGL//src//drivers//display//st7796//: lv_st7796.c lv_st7796.h
    .//Middlewares//LVGL//src//drivers//display//st_ltdc//: lv_st_ltdc.c lv_st_ltdc.h
    .//Middlewares//LVGL//src//drivers//display//tft_espi//: lv_tft_espi.h
    .//Middlewares//LVGL//src//drivers//draw//eve//: lv_draw_eve_display.c lv_draw_eve_display.h lv_draw_eve_display_defines.h
    .//Middlewares//LVGL//src//drivers//evdev//: lv_evdev.c lv_evdev.h lv_evdev_private.h
    .//Middlewares//LVGL//src//drivers//libinput//: lv_libinput.c lv_libinput.h lv_libinput_private.h lv_xkb.c lv_xkb.h lv_xkb_private.h
    .//Middlewares//LVGL//src//drivers//nuttx//: lv_nuttx_cache.c lv_nuttx_cache.h lv_nuttx_entry.c lv_nuttx_entry.h lv_nuttx_fbdev.c lv_nuttx_fbdev.h lv_nuttx_image_cache.c lv_nuttx_image_cache.h lv_nuttx_lcd.c lv_nuttx_lcd.h lv_nuttx_libuv.c lv_nuttx_libuv.h lv_nuttx_mouse.c lv_nuttx_mouse.h lv_nuttx_profiler.c lv_nuttx_profiler.h lv_nuttx_touchscreen.c lv_nuttx_touchscreen.h
    .//Middlewares//LVGL//src//drivers//opengles//opengl_shader//: lv_opengl_shader_internal.h lv_opengl_shader_manager.c lv_opengl_shader_program.c
    .//Middlewares//LVGL//src//drivers//opengles//: lv_opengles_debug.c lv_opengles_debug.h lv_opengles_driver.c lv_opengles_driver.h lv_opengles_egl.c lv_opengles_egl.h lv_opengles_glfw.c lv_opengles_glfw.h lv_opengles_private.h lv_opengles_texture.c lv_opengles_texture.h lv_opengles_window.h
    .//Middlewares//LVGL//src//drivers//qnx//: lv_qnx.c lv_qnx.h
    .//Middlewares//LVGL//src//drivers//sdl//: lv_sdl_keyboard.c lv_sdl_keyboard.h lv_sdl_mouse.c lv_sdl_mouse.h lv_sdl_mousewheel.c lv_sdl_mousewheel.h lv_sdl_private.h lv_sdl_window.c lv_sdl_window.h
    .//Middlewares//LVGL//src//drivers//uefi//: lv_uefi.h lv_uefi_context.c lv_uefi_context.h lv_uefi_display.c lv_uefi_display.h lv_uefi_edk2.h lv_uefi_gnu_efi.h lv_uefi_indev.h lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c lv_uefi_private.h lv_uefi_std_wrapper.h
    .//Middlewares//LVGL//src//drivers//wayland//: lv_wayland.c lv_wayland.h lv_wayland_private.h lv_wayland_smm.c lv_wayland_smm.h lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_keyboard.h lv_wl_pointer.c lv_wl_pointer.h lv_wl_pointer_axis.c lv_wl_pointer_axis.h lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_touch.h lv_wl_window.c lv_wl_window.h lv_wl_window_decorations.c lv_wl_xdg_shell.c
    .//Middlewares//LVGL//src//drivers//windows//: lv_windows_context.c lv_windows_context.h lv_windows_display.c lv_windows_display.h lv_windows_input.c lv_windows_input.h lv_windows_input_private.h
    .//Middlewares//LVGL//src//drivers//x11//: lv_x11.h lv_x11_display.c lv_x11_input.c
    .//Middlewares//LVGL//src//drivers//: lv_drivers.h
    .//Middlewares//LVGL//src//font//: lv_binfont_loader.c lv_binfont_loader.h lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_fmt_txt_private.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
    .//Middlewares//LVGL//src//indev//: lv_indev.c lv_indev.h lv_indev_gesture.c lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
    .//Middlewares//LVGL//src//layouts//flex//: lv_flex.c lv_flex.h
    .//Middlewares//LVGL//src//layouts//grid//: lv_grid.c lv_grid.h
    .//Middlewares//LVGL//src//layouts//: lv_layout.c lv_layout.h lv_layout_private.h
    .//Middlewares//LVGL//src//libs//barcode//: code128.c code128.h lv_barcode.c lv_barcode.h lv_barcode_private.h
    .//Middlewares//LVGL//src//libs//bin_decoder//: lv_bin_decoder.c lv_bin_decoder.h
    .//Middlewares//LVGL//src//libs//bmp//: lv_bmp.c lv_bmp.h
    .//Middlewares//LVGL//src//libs//expat//: ascii.h asciitab.h expat.h expat_config.h expat_external.h iasciitab.h internal.h latin1tab.h nametab.h siphash.h utf8tab.h winconfig.h xmlparse.c xmlrole.c xmlrole.h xmltok.c xmltok.h xmltok_impl.c xmltok_impl.h xmltok_ns.c
    .//Middlewares//LVGL//src//libs//ffmpeg//: lv_ffmpeg.c lv_ffmpeg.h lv_ffmpeg_private.h
    .//Middlewares//LVGL//src//libs//freetype//: ftmodule.h ftoption.h lv_freetype.c lv_freetype.h lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype_private.h lv_ftsystem.c
    .//Middlewares//LVGL//src//libs//fsdrv//: lv_fsdrv.h lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    .//Middlewares//LVGL//src//libs//FT800-FT813//: EVE.h EVE_commands.c EVE_commands.h EVE_config.h EVE_supplemental.c EVE_suppplemental.h EVE_target.h
    .//Middlewares//LVGL//src//libs//gif//AnimatedGIF//src//: AnimatedGIF.h gif.c
    .//Middlewares//LVGL//src//libs//gif//: lv_gif.c lv_gif.h
    .//Middlewares//LVGL//src//libs//gltf//gltf_data//: lv_gltf_bind.h lv_gltf_data_internal.h lv_gltf_model.h
    .//Middlewares//LVGL//src//libs//gltf//gltf_view//assets//: lv_gltf_view_shader.c lv_gltf_view_shader.h pisa.c
    .//Middlewares//LVGL//src//libs//gltf//gltf_view//ibl//: lv_gltf_ibl_sampler.c lv_gltf_ibl_sampler.h
    .//Middlewares//LVGL//src//libs//gltf//gltf_view//: lv_gltf.h lv_gltf_view_internal.h
    .//Middlewares//LVGL//src//libs//gltf//stb_image//: stb_image.h
    .//Middlewares//LVGL//src//libs//gstreamer//: lv_gstreamer.c lv_gstreamer.h lv_gstreamer_internal.h
    .//Middlewares//LVGL//src//libs//libjpeg_turbo//: lv_libjpeg_turbo.c lv_libjpeg_turbo.h
    .//Middlewares//LVGL//src//libs//libpng//: lv_libpng.c lv_libpng.h
    .//Middlewares//LVGL//src//libs//lodepng//: lodepng.c lodepng.h lv_lodepng.c lv_lodepng.h
    .//Middlewares//LVGL//src//libs//lz4//: lz4.c lz4.h
    .//Middlewares//LVGL//src//libs//qrcode//: lv_qrcode.c lv_qrcode.h lv_qrcode_private.h qrcodegen.c qrcodegen.h
    .//Middlewares//LVGL//src//libs//rle//: lv_rle.c lv_rle.h
    .//Middlewares//LVGL//src//libs//rlottie//: lv_rlottie.c lv_rlottie.h lv_rlottie_private.h
    .//Middlewares//LVGL//src//libs//svg//: lv_svg.c lv_svg.h lv_svg_decoder.c lv_svg_decoder.h lv_svg_parser.c lv_svg_parser.h lv_svg_render.c lv_svg_render.h lv_svg_token.c lv_svg_token.h
    .//Middlewares//LVGL//src//libs//thorvg//rapidjson//error//: en.h error.h
    .//Middlewares//LVGL//src//libs//thorvg//rapidjson//internal//: biginteger.h clzll.h diyfp.h dtoa.h ieee754.h itoa.h meta.h pow10.h regex.h stack.h strfunc.h strtod.h swap.h
    .//Middlewares//LVGL//src//libs//thorvg//rapidjson//msinttypes//: inttypes.h stdint.h
    .//Middlewares//LVGL//src//libs//thorvg//rapidjson//: allocators.h cursorstreamwrapper.h document.h encodedstream.h encodings.h filereadstream.h filewritestream.h fwd.h istreamwrapper.h memorybuffer.h memorystream.h ostreamwrapper.h pointer.h prettywriter.h rapidjson.h reader.h schema.h stream.h stringbuffer.h uri.h writer.h
    .//Middlewares//LVGL//src//libs//thorvg//: config.h thorvg.h thorvg_capi.h thorvg_lottie.h tvgAnimation.h tvgArray.h tvgBinaryDesc.h tvgCanvas.h tvgCommon.h tvgCompressor.h tvgFill.h tvgFrameModule.h tvgInlist.h tvgIteratorAccessor.h tvgLoader.h tvgLoadModule.h tvgLock.h tvgLottieBuilder.h tvgLottieCommon.h tvgLottieExpressions.h tvgLottieInterpolator.h tvgLottieLoader.h tvgLottieModel.h tvgLottieModifier.h tvgLottieParser.h tvgLottieParserHandler.h tvgLottieProperty.h tvgLottieRenderPooler.h tvgMath.h tvgPaint.h tvgPicture.h tvgRawLoader.h tvgRender.h tvgSaveModule.h tvgScene.h tvgShape.h tvgStr.h tvgSvgCssStyle.h tvgSvgLoader.h tvgSvgLoaderCommon.h tvgSvgPath.h tvgSvgSceneBuilder.h tvgSvgUtil.h tvgSwCommon.h tvgSwRasterAvx.h tvgSwRasterC.h tvgSwRasterNeon.h tvgSwRasterTexmap.h tvgSwRenderer.h tvgTaskScheduler.h tvgText.h tvgXmlParser.h
    .//Middlewares//LVGL//src//libs//tiny_ttf//: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
    .//Middlewares//LVGL//src//libs//tjpgd//: lv_tjpgd.c lv_tjpgd.h tjpgd.c tjpgd.h tjpgdcnf.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//inc//: vg_lite.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//lv_vg_lite_hal//: lv_vg_lite_hal.c vg_lite_platform.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//VGLite//Series//gc255//0x40A//: vg_lite_options.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//VGLite//Series//gc355//0x0_1215//: vg_lite_options.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//VGLite//Series//gc355//0x0_1216//: vg_lite_options.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//VGLite//Series//gc555//0x423//: vg_lite_options.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//VGLite//Series//gc555//0x423_ECO//: vg_lite_options.h
    .//Middlewares//LVGL//src//libs//vg_lite_driver//VGLite//: vg_lite.c vg_lite_context.h vg_lite_image.c vg_lite_matrix.c vg_lite_options.h vg_lite_path.c vg_lite_stroke.c
    .//Middlewares//LVGL//src//libs//vg_lite_driver//VGLiteKernel//: vg_lite_debug.h vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h vg_lite_option.h vg_lite_type.h
    .//Middlewares//LVGL//src//misc//cache//class//: lv_cache_class.h lv_cache_lru_ll.c lv_cache_lru_ll.h lv_cache_lru_rb.c lv_cache_lru_rb.h lv_cache_sc_da.c lv_cache_sc_da.h
    .//Middlewares//LVGL//src//misc//cache//instance//: lv_cache_instance.h lv_image_cache.c lv_image_cache.h lv_image_header_cache.c lv_image_header_cache.h
    .//Middlewares//LVGL//src//misc//cache//: lv_cache.c lv_cache.h lv_cache_entry.c lv_cache_entry.h lv_cache_entry_private.h lv_cache_private.h
    .//Middlewares//LVGL//src//misc//: lv_anim.c lv_anim.h lv_anim_private.h lv_anim_timeline.c lv_anim_timeline.h lv_anim_timeline_private.h lv_area.c lv_area.h lv_area_private.h lv_array.c lv_array.h lv_assert.c lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_bidi_private.h lv_circle_buf.c lv_circle_buf.h lv_color.c lv_color.h lv_color_op.c lv_color_op.h lv_color_op_private.h lv_event.c lv_event.h lv_event_private.h lv_fs.c lv_fs.h lv_fs_private.h lv_grad.c lv_grad.h lv_iter.c lv_iter.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_matrix.c lv_matrix.h lv_palette.c lv_palette.h lv_profiler.h lv_profiler_builtin.c lv_profiler_builtin.h lv_profiler_builtin_posix.c lv_profiler_builtin_private.h lv_rb.c lv_rb.h lv_rb_private.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_style_private.h lv_templ.c lv_templ.h lv_text.c lv_text.h lv_text_ap.c lv_text_ap.h lv_text_private.h lv_timer.c lv_timer.h lv_timer_private.h lv_tree.c lv_tree.h lv_types.h lv_utils.c lv_utils.h
    .//Middlewares//LVGL//src//osal//: lv_cmsis_rtos2.c lv_cmsis_rtos2.h lv_freertos.c lv_freertos.h lv_linux.c lv_linux_private.h lv_mqx.c lv_mqx.h lv_os.c lv_os.h lv_os_none.c lv_os_none.h lv_os_private.h lv_pthread.c lv_pthread.h lv_rtthread.c lv_rtthread.h lv_sdl2.c lv_sdl2.h lv_windows.c lv_windows.h
    .//Middlewares//LVGL//src//others//file_explorer//: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
    .//Middlewares//LVGL//src//others//font_manager//: lv_font_manager.c lv_font_manager.h lv_font_manager_recycle.c lv_font_manager_recycle.h
    .//Middlewares//LVGL//src//others//fragment//: lv_fragment.c lv_fragment.h lv_fragment_manager.c lv_fragment_private.h
    .//Middlewares//LVGL//src//others//gridnav//: lv_gridnav.c lv_gridnav.h
    .//Middlewares//LVGL//src//others//ime//: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
    .//Middlewares//LVGL//src//others//imgfont//: lv_imgfont.c lv_imgfont.h
    .//Middlewares//LVGL//src//others//monkey//: lv_monkey.c lv_monkey.h lv_monkey_private.h
    .//Middlewares//LVGL//src//others//observer//: lv_observer.c lv_observer.h lv_observer_private.h
    .//Middlewares//LVGL//src//others//snapshot//: lv_snapshot.c lv_snapshot.h
    .//Middlewares//LVGL//src//others//sysmon//: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
    .//Middlewares//LVGL//src//others//test//: lv_test.h lv_test_display.c lv_test_display.h lv_test_helpers.c lv_test_helpers.h lv_test_indev.c lv_test_indev.h lv_test_indev_gesture.c lv_test_indev_gesture.h lv_test_private.h lv_test_screenshot_compare.c lv_test_screenshot_compare.h
    .//Middlewares//LVGL//src//others//translation//: lv_translation.c lv_translation.h lv_translation_private.h
    .//Middlewares//LVGL//src//others//vg_lite_tvg//: vg_lite.h vg_lite_matrix.c
    .//Middlewares//LVGL//src//others//xml//parsers//: lv_xml_arc_parser.c lv_xml_arc_parser.h lv_xml_bar_parser.c lv_xml_bar_parser.h lv_xml_buttonmatrix_parser.c lv_xml_buttonmatrix_parser.h lv_xml_button_parser.c lv_xml_button_parser.h lv_xml_calendar_parser.c lv_xml_calendar_parser.h lv_xml_canvas_parser.c lv_xml_canvas_parser.h lv_xml_chart_parser.c lv_xml_chart_parser.h lv_xml_checkbox_parser.c lv_xml_checkbox_parser.h lv_xml_dropdown_parser.c lv_xml_dropdown_parser.h lv_xml_image_parser.c lv_xml_image_parser.h lv_xml_keyboard_parser.c lv_xml_keyboard_parser.h lv_xml_label_parser.c lv_xml_label_parser.h lv_xml_obj_parser.c lv_xml_obj_parser.h lv_xml_qrcode_parser.c lv_xml_qrcode_parser.h lv_xml_roller_parser.c lv_xml_roller_parser.h lv_xml_scale_parser.c lv_xml_scale_parser.h lv_xml_slider_parser.c lv_xml_slider_parser.h lv_xml_spangroup_parser.c lv_xml_spangroup_parser.h lv_xml_switch_parser.c lv_xml_switch_parser.h lv_xml_table_parser.c lv_xml_table_parser.h lv_xml_tabview_parser.c lv_xml_tabview_parser.h lv_xml_textarea_parser.c lv_xml_textarea_parser.h
    .//Middlewares//LVGL//src//others//xml//: lv_xml.c lv_xml.h lv_xml_base_types.c lv_xml_base_types.h lv_xml_component.c lv_xml_component.h lv_xml_component_private.h lv_xml_load.c lv_xml_load.h lv_xml_parser.c lv_xml_parser.h lv_xml_private.h lv_xml_style.c lv_xml_style.h lv_xml_test.c lv_xml_test.h lv_xml_translation.c lv_xml_translation.h lv_xml_update.c lv_xml_update.h lv_xml_utils.c lv_xml_utils.h lv_xml_widget.c lv_xml_widget.h
    .//Middlewares//LVGL//src//stdlib//builtin//: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
    .//Middlewares//LVGL//src//stdlib//clib//: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    .//Middlewares//LVGL//src//stdlib//micropython//: lv_mem_core_micropython.c
    .//Middlewares//LVGL//src//stdlib//rtthread//: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    .//Middlewares//LVGL//src//stdlib//uefi//: lv_mem_core_uefi.c
    .//Middlewares//LVGL//src//stdlib//: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
    .//Middlewares//LVGL//src//themes//default//: lv_theme_default.c lv_theme_default.h
    .//Middlewares//LVGL//src//themes//mono//: lv_theme_mono.c lv_theme_mono.h
    .//Middlewares//LVGL//src//themes//simple//: lv_theme_simple.c lv_theme_simple.h
    .//Middlewares//LVGL//src//themes//: lv_theme.c lv_theme.h lv_theme_private.h
    .//Middlewares//LVGL//src//tick//: lv_tick.c lv_tick.h lv_tick_private.h
    .//Middlewares//LVGL//src//widgets//3dtexture//: lv_3dtexture.c lv_3dtexture.h lv_3dtexture_private.h
    .//Middlewares//LVGL//src//widgets//animimage//: lv_animimage.c lv_animimage.h lv_animimage_private.h
    .//Middlewares//LVGL//src//widgets//arc//: lv_arc.c lv_arc.h lv_arc_private.h
    .//Middlewares//LVGL//src//widgets//arclabel//: lv_arclabel.c lv_arclabel.h lv_arclabel_private.h
    .//Middlewares//LVGL//src//widgets//bar//: lv_bar.c lv_bar.h lv_bar_private.h
    .//Middlewares//LVGL//src//widgets//button//: lv_button.c lv_button.h lv_button_private.h
    .//Middlewares//LVGL//src//widgets//buttonmatrix//: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
    .//Middlewares//LVGL//src//widgets//calendar//: lv_calendar.c lv_calendar.h lv_calendar_chinese.c lv_calendar_chinese.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_calendar_private.h
    .//Middlewares//LVGL//src//widgets//canvas//: lv_canvas.c lv_canvas.h lv_canvas_private.h
    .//Middlewares//LVGL//src//widgets//chart//: lv_chart.c lv_chart.h lv_chart_private.h
    .//Middlewares//LVGL//src//widgets//checkbox//: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
    .//Middlewares//LVGL//src//widgets//dropdown//: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
    .//Middlewares//LVGL//src//widgets//image//: lv_image.c lv_image.h lv_image_private.h
    .//Middlewares//LVGL//src//widgets//imagebutton//: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
    .//Middlewares//LVGL//src//widgets//keyboard//: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
    .//Middlewares//LVGL//src//widgets//label//: lv_label.c lv_label.h lv_label_private.h
    .//Middlewares//LVGL//src//widgets//led//: lv_led.c lv_led.h lv_led_private.h
    .//Middlewares//LVGL//src//widgets//line//: lv_line.c lv_line.h lv_line_private.h
    .//Middlewares//LVGL//src//widgets//list//: lv_list.c lv_list.h
    .//Middlewares//LVGL//src//widgets//lottie//: lv_lottie.c lv_lottie.h lv_lottie_private.h
    .//Middlewares//LVGL//src//widgets//menu//: lv_menu.c lv_menu.h lv_menu_private.h
    .//Middlewares//LVGL//src//widgets//msgbox//: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
    .//Middlewares//LVGL//src//widgets//objx_templ//: lv_objx_templ.c lv_objx_templ.h
    .//Middlewares//LVGL//src//widgets//property//: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_obj_property_names.h lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_style_properties.h lv_textarea_properties.c
    .//Middlewares//LVGL//src//widgets//roller//: lv_roller.c lv_roller.h lv_roller_private.h
    .//Middlewares//LVGL//src//widgets//scale//: lv_scale.c lv_scale.h lv_scale_private.h
    .//Middlewares//LVGL//src//widgets//slider//: lv_slider.c lv_slider.h lv_slider_private.h
    .//Middlewares//LVGL//src//widgets//span//: lv_span.c lv_span.h lv_span_private.h
    .//Middlewares//LVGL//src//widgets//spinbox//: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
    .//Middlewares//LVGL//src//widgets//spinner//: lv_spinner.c lv_spinner.h
    .//Middlewares//LVGL//src//widgets//switch//: lv_switch.c lv_switch.h lv_switch_private.h
    .//Middlewares//LVGL//src//widgets//table//: lv_table.c lv_table.h lv_table_private.h
    .//Middlewares//LVGL//src//widgets//tabview//: lv_tabview.c lv_tabview.h lv_tabview_private.h
    .//Middlewares//LVGL//src//widgets//textarea//: lv_textarea.c lv_textarea.h lv_textarea_private.h
    .//Middlewares//LVGL//src//widgets//tileview//: lv_tileview.c lv_tileview.h lv_tileview_private.h
    .//Middlewares//LVGL//src//widgets//win//: lv_win.c lv_win.h lv_win_private.h
    .//Middlewares//LVGL//src//: lvgl.h lvgl_private.h lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_api_map_v9_2.h lv_api_map_v9_3.h lv_conf_internal.h lv_conf_kconfig.h lv_init.c lv_init.h
    .//Middlewares//LVGL//: lvgl.h lvgl_private.h lv_conf.h lv_version.h
  group ComFunc
    ./ComFunc/: check.c filtration.c function.c i2c.c ntc.c queue_task.c
  group Application
    ./Application/: board_config.h FreeRTOSConfig.h main.c board_config.c app_info.c gpio_init.c fwdgt.c gd32f30x_it.c timer_task.c
  group App-Sys
    ./Application/Sys/: sys_task.c sys_task.h sys_queue_task.c sys_queue_task.h sys_queue_task_init.c sys_queue_task_closing.c sys_queue_task_shut_down.c sys_queue_task_booting.c sys_queue_task_work.c sys_queue_task_err.c sys_queue_task_reset.c sys_queue_task_eng.c sys_queue_task_eng.h sys_queue_task_updata.c sys_queue_task_updata.h
  group HW-Flash
    ./Hardware/Flash/: flash_gd32.c flash_iface.c
  group HW-Print
    ./Hardware/Print/: print_task.c print_task.h print_queue_task.c print_queue_task.h print_queue_task_main.c print_queue_task_reply_cali.c print_queue_task_reply_app_info.c print_queue_task_updata.c print_prot_frame.c print_prot_frame.h print_api.c print_api.h print_iface.c print_iface.h
  group HW-Adc
    ./Hardware/Adc/: adc_task.c adc_task.h adc_iface.c adc_iface.h
  group HW-Key
    ./Hardware/Key/: key_task.c key_task.h key_func.c key_func.h key_func_eng.c key_func_eng.h
  group HW-Buz
    ./Hardware/Buz/: buz_task.c buz_task.h buz_iface.c buz_iface.h
  group HW-Dc
    ./Hardware/Dc/: dc_task.c dc_task.h dc_iface.c dc_iface.h
  group HW-Usb
    ./Hardware/Usb/: usb_task.c usb_task.h usb_iface.c usb_iface.h usb_prot_frame.c usb_prot_frame.h usb_queue_task.c usb_queue_task.h usb_queue_task_booting.c usb_queue_task_closing.c usb_queue_task_err.c usb_queue_task_init.c usb_queue_task_work.c
  group HW-Led
    ./Hardware/Led/: led_task.c led_task.h led_iface.c led_iface.h
  group HW-MD_Display
    .//Hardware//MD_Display//: lv_port_disp.c lv_port_disp.h lv_port_tft_disp.h lv_port_tft_gpio.h lv_port_timer.c lv_port_timer.h md_display_api.c md_display_api.h md_display_eng_mode.c md_display_eng_mode.h md_display_err.c md_display_iface.c md_display_iface.h md_display_queue_task.c md_display_queue_task.h md_display_queue_task_booting.c md_display_queue_task_closing.c md_display_queue_task_eng.c md_display_queue_task_err.c md_display_queue_task_init.c md_display_queue_task_shut_down.c md_display_queue_task_updata.c md_display_queue_task_work.c md_display_task.c md_display_task.h tft_minimal_demo.c
  group HW-MD_Light
    ./Hardware/MD_Light/: md_light_task.c md_light_task.h md_light_iface.c md_light_iface.h
  group HW-MD_HeatManage
    ./Hardware/MD_HeatManage/: md_hm_task.c md_hm_task.h md_hm_iface.c md_hm_iface.h
  group HW-MD_Bms
    ./Hardware/MD_Bms/: md_bms_task.c md_bms_task.h md_bms_queue_task.c md_bms_queue_task.h md_bms_queue_task_init.c md_bms_queue_task_main.c md_bms_queue_task_ctrl_switch.c md_bms_queue_task_cali.c md_bms_queue_task_err.c md_bms_queue_task_get_app_info.c md_bms_queue_task_req_set_cmd.c md_bms_queue_task_updata.c md_bms_rec_task.c md_bms_rec_task.h md_bms_rec_data_proc.c md_bms_rec_data_proc.h md_bms_prot_frame.c md_bms_prot_frame.h md_bms_iface.c md_bms_iface.h
  group HW-MD_Mppt
    ./Hardware/MD_Mppt/: md_mppt_task.c md_mppt_task.h md_mppt_queue_task.c md_mppt_queue_task.h md_mppt_queue_task_init.c md_mppt_queue_task_main.c md_mppt_queue_task_err_process.c md_mppt_queue_task_set_chg_pwr.c md_mppt_rec_task.c md_mppt_rec_task.h md_mppt_rec_data_proc.c md_mppt_rec_data_proc.h md_mppt_prot_frame.c md_mppt_prot_frame.h
  group HW-MD_Dcac
    ./Hardware/MD_Dcac/: md_dcac_task.c md_dcac_task.h md_dcac_queue_task.c md_dcac_queue_task.h md_dcac_queue_task_init.c md_dcac_queue_task_main.c md_dcac_queue_task_dcac_in.c md_dcac_queue_task_dcac_out.c md_dcac_queue_task_para_in.c md_dcac_queue_task_err_proc.c md_dcac_rec_task.c md_dcac_rec_task.h md_dcac_rec_data_proc.c md_dcac_rec_data_proc.h md_dcac_prot_frame.c md_dcac_prot_frame.h md_dcac_iface.c md_dcac_iface.h
